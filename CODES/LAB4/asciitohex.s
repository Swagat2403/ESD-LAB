	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0,=SRC1
	LDR R1,=DST
	MOV R2,#04
	LDR R3,[R0]
	
UP
	AND R4,R3,#0XFF
	CMP R4,#0X40
	SUBHI R4,#07
	SUB R4,#0X30
	ADD R5,R4
	ROR R5,#28
	LSR R3,#8
	SUBS R2,#1
	BNE UP
	LDR R3,[R0,#4]
	MOV R2,#4
	
UP2 
	AND R4,R3,#0XFF
	CMP R4,#0X40
	SUBHI R4,#07
	SUB R4,#0X30
	ADD R5,R4
	ROR R5,#28
	LSR R3,#8
	SUBS R2,#1
	BNE UP2
	ROR R5,#4
	STR R5,[R1]
STOP
	B STOP
SRC1 DCD 0X31433839,0X45303236
	AREA data,DATA,READWRITE
DST DCD 0
	END
	