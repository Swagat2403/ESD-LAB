	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R4,=NUM
	LDR R0,[R4]
	LDR R1,=0X01
	LDR R2,=FACT
	LDR R13,=0X10001000
	
	
	
	
FACT1 

	PUSH{LR}
	PUSH{R0}
	SUB R0,#1
	TEQ R0,#0
	BLNE FACT1
	POP {R0}
	POP{LR}
	MUL R1,R0
	STR R1,[R2]
	BX LR
	
	LDR R11,[R2]
	
	
STOP B STOP
NUM DCD 0X07
	AREA data,DATA,READWRITE
FACT DCD 0
	END
	